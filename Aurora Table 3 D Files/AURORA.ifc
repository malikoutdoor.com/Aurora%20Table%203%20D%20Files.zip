Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T11:33:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 11:33:29 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{56D0EC2C-92FE-43C7-B993-F95117A36018}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 11:33:27 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 11:33:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 11:33:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR091 - UTC 7, Tavolo AURORA:0PAAR091 - UTC 7:135734
In: 0 - Piano Terra
Type - Material: UTC 7
Type - Altro - Categoria: Modelli generici; Nome famiglia: Tavolo AURORA
Type - Dati identità - BIM Name: AURORA; BIM Object Type: Tavoli - Tables; Code: 0PAAR091; Designer: BELLITALIA DESIGN; Family Name: AURORA; Nome del tipo: 0PAAR091 - UTC 7; URL Eng: https://www.bellitalia.net/en/products/tables/aurora/; URL Ita: https://www.bellitalia.net/prodotti/tavoli/aurora/
Type - Dimensioni - Dimensions: 2250 mm x 900 mm x 750 mm
Type - Generale - Descrizione Tecnica Famiglia: Il tavolo mod. ”AURORA”, è costituito da un tavolo monolitico a sezione triangolare con una leggera bombatura sulla superficie superiore che favorisce il deflusso delle acque. Questo prodotto, appartenete alla famiglia dei prodotti in Ultratense Concrete® e sfrutta al massimo la tecnologia innovativa e le eccezionali resistenze proprie di questo materiale. Ne deriva un prodotto con un motivo formale molto leggero ed elegante, dove una serie di pieghe seguono una logica ergonomica minimale e rigorosa, sostenuta da un profilo centrale che emerge dalle superfici inferiori, senza, al contempo, appesantirne l’aspetto. Il tavolo è concepito per essere abbinato alla panca ”ALBA”.; Descrizione Tecnica per Codice: TAVOLO AURORA IN UTC 7 - BIANCO LISCIO CASSERO VERNICIATURA ANTI-DEGRADO; Fissaggio: Barre filettate per ancoraggio a terra; Fixings: threaded rods for ground anchoring; Technical Description Family: The "AURORA" table model consists of a monolithic triangular section table with a slight curvature on the upper surface, facilitating water drainage. This product belongs to the Ultratense Concrete® product family and maximizes the innovative technology and exceptional strengths of this material. The result is a product with a very light and elegant formal pattern, where a series of folds follow a minimal and rigorous ergonomic logic, supported by a central profile that emerges from the lower surfaces without weighing down its appearance. The table is designed to be paired with the "ALBA" bench.; Technical Description for Article: AURORA TABLE IN UTC 7 - SMOOTH WHITE FORMWORK ANTI-DEGRADATION PAINTING
Type - Materiali e finiture - Materiale Principale: UTC 7; Materiale Secondario: UTC; MATERIALE SEDUTA: UTC 7; Primary Material: UTC 7; Secondary Material: UTC
Type - Meccanica - Weight ( kg): 479 kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR091 - UTC 7
Altro - Famiglia: Tavolo AURORA: 0PAAR091 - UTC 7; Famiglia e tipo: Tavolo AURORA: 0PAAR091 - UTC 7; ID tipo: Tavolo AURORA: 0PAAR091 - UTC 7; Tipo: Tavolo AURORA: 0PAAR091 - UTC 7
Dimensioni - Area: 3.07639 m2; Volume: 0.195449 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
